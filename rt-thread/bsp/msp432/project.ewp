# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSP432P401R TexasInstruments MSP432P401R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __TARGET_NAME__=msp432; __MSP432P401R__; ewarm
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\components\net\lwip-1.4.1\src; ..\..\..\components\mqtt\include; ..\..\components\net\lwip-1.4.1\src\include; drivers; ..\..\components\net\lwip-1.4.1\src\include\ipv4; startup; ..\..\components\net\lwip-1.4.1\src\include\netif; ..\..\components\external\paho-mqtt\MQTTPacket\src; .; ..\..\include; ..\..\libcpu\arm\cortex-m4; ..\..\components\drivers\include; msp432_driverlib_3_21_00_05\driverlib\MSP432P4xx; ..\..\libcpu\arm\common; ..\..\components\net\lwip-1.4.1\src\arch\include; ..\..\components\net\lwip-1.4.1\src\netif\ppp; msp432_driverlib_3_21_00_05\inc\CMSIS; msp432_driverlib_3_21_00_05\inc; ..\..\..\application
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\TexasInstruments\msp432p401r.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; uint_fast8_t=uint8_t; uint_fast16_t=uint16_t; uint_fast32_t=uint32_t; uint_fast64_t=uint64_t; uint_least32_t=uint32_t
  ICCARM.CCOptLevel: 3
  group application
    ../../../application/: app-main.c
  group CORTEX-M4
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
    ../../components/drivers/serial/: serial.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group LwIP
    ../../components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip-1.4.1/src/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
    ../../components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
    ../../components/net/lwip-1.4.1/src/arch/: sys_arch.c
  group msp432_driverlib
    msp432_driverlib_3_21_00_05/driverlib/MSP432P4xx/: adc14.c aes256.c comp_e.c cpu.c crc32.c cs.c dma.c flash.c fpu.c gpio.c i2c.c interrupt.c mpu.c pcm.c pmap.c pss.c ref_a.c reset.c rtc_c.c spi.c sysctl.c systick.c timer32.c timer_a.c uart.c wdt_a.c
  group paho-mqtt
    ../../components/external/paho-mqtt/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group paho-mqtt-rtthread
    ../../../components/mqtt/zephyr-mqtt/: mqtt_pkt.c
  group startup
    drivers/: board.c hw_serial.c
    startup/: msp432_startup_ewarm.c startup-main.c system_msp432p401r.c
